# Repository MuroBox/MuroBox-USB

File README.md:

# Arduino Project for Muro Box USB Interface
# Introduction

This project is dedicated to the development of the Muro Box USB interface, providing additional means of MIDI input to the Muro Box. As of now, the USB interface supports USB MIDI Keyboard, USB flash drive, and PC USB MIDI output. 

Muro Box is the world’s first App-controlled music box. For more information on Muro Box: [Muro Box official website](https://murobox.com/en/)  

# Overview of the Project
This is an Arduino project that runs on an ESP8266 chip to serve as an add-on board to the motherboard of the Muro Box. 

The add-on features can be deconstructed into two main subsystems. First, Muro Box acts as a host device supporting peripheral devices: USB MIDI Keyboard and USB flash drive. Second, Muro Box acts as a peripheral device connecting to a host device, for USB MIDI output from a PC (Windows /macOS). 

This project is heavily based on [USB Host Shileld](https://chome.nerpa.tech/arduino_usb_host_shield_projects/) project, a MAX3421E-based USB Host Shield Library.

## Schematic and PCB Layout 
[MuroBox-USB-schematic](hardware/MuroBox-USB-schematic.pdf)  
[MuroBox-USB-pcb](hardware/MuroBox-USB-pcb.pdf)  

The add-on board is connected to the motherboard with only a few wire connections.  
- UART is used for serial communication (MIDI) between ESP8266 and the chip on the motherboard.
- PACK_INT is used for signaling the motherboard entering add-on UART mode.
- PACK_N_RESET is used for asserting the RES Pin on ESP8266 and MAX3421E
- 3.3 and 5-volt power supply and GND
- Rotary Encoder PINs for the knob (bypass ESP8266)

## Detection and Transition between Host Mode and Peripheral Mode

The MAX3421E adds USB host or peripheral capability to any system with an SPI interface. A mechanism is developed to automatically identify peripheral or host external devices and initialize the MAX3421E accordingly. The logic behind the mechanism is explained down below:

Vbus is wired to a Vbus comparator in MAX3421. Vbus makes a 0-1 transition when either a host or peripheral device plugs in. GPIO6 of MAX3421 is connected to an output pin (ID) of TUSB320. TUSB320 uses the CC pins to determine port attach and detach, cable orientation, role detection, and port control for Type-C current mode. A Vbus transition with GPIO6 in high voltage level indicates a peripheral device is plugged in. On the other hand, a Vbus transition without GPIO6 in a high voltage level indicates a host device is plugged in. When a device is detached, Vbus makes a 1-0 transition.
            
|      | VBUS | GPIO6 |
|------|------|-------|
|DEVICE|  0-1 |   1   |
| HOST |  0-1 |   0   |
|DETACH|  1-0 |   0   |

Once the device is being detected and identified, the corresponding subsystem will be executed.
## Host Mode

Four major components are running in host mode.

-   **MuroBoxUSBHostLoop**
The MuroBoxUSBHostLoop performs connectivity detection and enumeration for peripheral devices.

-   **MuroBoxMIDILoop**
The MuroBoxMIDILoop supports functionalities of MIDI devices (MIDI keyboard) and parsing MIDI SysEx messages received from the motherboard. 

-   **MuroBoxUsbFATLoop**
The MuroBoxUsbFATLoop supports mass storage devices (USB flash drive) and file handling.

-   **MuroBoxMIDIPlayerLoop**
The MuroBoxMIDIPlayerLoop contains a state machine allowing users to scan, play, pause and traverse MIDI music files stored in a USB flash drive with ease.

### External Dependencies
Multiple libraries are integrated into this subsystem with modifications. Changes are listed below:
- [MD_MIDIFile-main](https://github.com/MajicDesigns/MD_MIDIFile): replace filesystem library from SdFat to [FatFs](http://elm-chan.org/fsw/ff/00index_e.html) for compatibility with [generic_storage](https://github.com/xxxajk/generic_storage).
- [MIDI_Library-5.0.2](https://www.arduino.cc/reference/en/libraries/midi-library/): change settings to allow multiple bytes parsing for SysEx messages and allow 0xFD as a defined command byte.
- [USB_Host_Shield_Library_2.0](https://github.com/felis/USB_Host_Shield_2.0): replace RTClib with ezTime, remove xmem2, take out unused source files, and handel watchdog reset (WDT) specifically for ESP8266. (Version: Feb 29, 2020. Please check its [GitHub page](https://github.com/felis/USB_Host_Shield_2.0)  for  newer commits)

## Peripheral Mode
**MuroBoxPeripheralLoop**
The process for enumerating as a MIDI device is similar to enumerating an HID keyboard demonstrated in the application note provided by Maxim. For a detailed explanation of the code, please reference the application note [USB Enumeration Code (and More) for the MAX3420E](https://www.maximintegrated.com/en/design/technical-documents/app-notes/3/3690.html).

There are a few differences between the MuroBoxPeripheralLoop and the Maxim application note: 
- The Configuration Descriptor is tailored for MIDI devices instead of HID devices.
- Process Out Token Packet instead of IN Token Packet
- Take out Suspend/Resume Feature

# Environment Setup

## Getting Started -- Arduino on ESP8266

- Step 1: Install the [Arduino Desktop IDE](https://www.arduino.cc/en/Guide
)

- Step 2: Download and unzip or clone the repository “Muro_box-Addon”. 
Note: the folder name has to be the same as the .ino file.
- Step 3: Config IDE 
    > - Start Arduino IDE and open the preference window.
    > - Copy and paste Board Manager URL to your preferences
    > Arduino >> preference -> Additional boards manager URLs: http://arduino.esp8266.com/stable/package_esp8266com_index.json
    > - Arduino >> Tools >> board >> boards manager -> install esp8266
    > - Arduino >> Tools >> board: select Generic ESP8266 Module 
    
    More Info: [how-to-install-esp8266-board-arduino-ide](https://randomnerdtutorials.com/how-to-install-esp8266-board-arduino-ide/)

- Step 4: Config setting options under the “Tool” menu
     > Board: "Generic ESP8266 Module"  
     Builtin Led: "O"  
     Upload Speed: "115200"  
     CPU Frequency: "160 MHz"  
     Crystal Frequency: "26 MHz"  
     Flash Size: "2MB (FS:512KB OTA:~768KB)"  
     Flash Mode: "QI0 (fast)"  
     Flash Frequency: "80MHz"  
     Reset Method: "dtr (aka nodemcu)"  
     Debug port: "Disabled"  
     Debug Level: "None"  
     IwIP Variant: "v2 Lower Memory"  
     VTables: "Flash"  
     Exceptions: "Legacy (new can return nullptr)"  
      Erase Flash: "Only Sketch"  
    Espressif FW: "nonos-sdk 2.2.1+119 (191122)"  
    SSL Support: "Basic SSL ciphers (lower ROM use)"  
    
 - Step 5: Install Arduino Libraries from Arduino Library Manager in IDE 
	> Arduino >> Tools >> Manage Libraries
	Install the following libraries: 
	>>ArduinoJson (by Benoit Blanchon)   
	ezTime (by Rop Gonggrijp)

- Step 6: Install User-Installed Libraries  
	User-installed libraries should be installed in the sketchbook libraries folder.  
	Create symbolic links to properly include all libraries from this repository.  
    >  **source folder <- symbolic link** 
    > `ln -s source_path symbolic_link`(for macOS)
    >>**symbolic links location**:   "libraries" folder inside Arduino sketchbook
    >> (The path to the sketchbook folder can be found in Arduino >> preference -> Sketchbook location)  
    >> **source folders**:  
    >> Muro_box-Addon/libraries/ESPSoftwareSerial  
    >> Muro_box-Addon/libraries/generic_storage  
    >> Muro_box-Addon/libraries/MD_MIDIFile-main  
    >> Muro_box-Addon/libraries/MIDI_Library-5.0.2  
    >> Muro_box-Addon/libraries/USB_Host_Shield_Library_2.0  

	More Info: [Installing Libraries Manually](https://learn.adafruit.com/adafruit-all-about-arduino-libraries-install-use/how-to-install-a-library)
- The final directory tree should look like this: 
```
Muro_box-Addon
 └── libraries
      ├── ESPSoftwareSerial
      ├── MD_MIDIFile-main
      ├── MIDI_Library-5.0.2
      ├── USB_Host_Shield_Library_2.0
      └── generic_storage
```
```
Arduino
 └── libraries
      ├── ArduinoJson
      ├── ezTime
      ├── ESPSoftwareSerial -> ../Muro_box-Addon/libraries/ESPSoftwareSerial
      ├── MD_MIDIFile-main -> ../Muro_box-Addon/libraries/MD_MIDIFile-main
      ├── MIDI_Library-5.0.2 -> ../Muro_box-Addon/libraries/MIDI_Library-5.0.2
      ├── USB_Host_Shield_Library_2.0 -> ../Muro_box-Addon/libraries/USB_Host_Shield_Library_2.0
      └── generic_storage -> ../Muro_box-Addon/libraries/generic_storage
```

## Hardware Setup

Solder a 2 pin 2.54 mm connector plug female on J3 and two 3 pin 2.0 mm connector plug female on MIDI and DEBUG port, demonstrated down below. 

- MIDI: mainly used as the default serial port for uploading Arduino sketches, and MIDI communication between the subboard and the motherboard. 
- DEBUG: mainly used for software serial print (baud rate: 115200)
- J3: mainly used for entering flash download mode by wire GPIO0 to ground with a jumper

A USB to TTL Converter Module with 3 pin connector plug male is also needed. Recommended models: TTL-232R-3V3

## Compile and Upload Sketch
There are two ways to compile and upload a sketch:
-   UART Update in Arduino IDE
	1.  Choose the correct serial port under the Tool menu
	2.  Connect J3 with a jumper
	3.  Connect serial port to the MIDI connector plug
	4.  Put ESP8266 into download mode by power reset or pushing the reset button on the motherboard
	5.  Click the Upload icon on the IDE.
	6. If an error persistently occurred while uploading the sketch, temporarily remove the RXD pin connection and try again 

-   OTA Update Using Web Browser
	1.  In Arduino IDE, Arduino >> Sketch >> Export Compiled Binary  
	2.  Establish Wi-Fi connection on PC to ESP8266 named MuroBox-Addon-Webupdate
	3.  Visit http://MuroBox-Addon-Webupdate.local/update in any browser 
	4.  Upload the binary file to update firmware (usually found in project repository, named Muro_box-Addon.ino.generic.bin)
	5.  The ESP8266 will reboot with the updated firmware.
	 
	 More information about [OTA Updates](https://arduino-esp8266.readthedocs.io/en/latest/ota_updates/readme.html)
## Useful Links
- [MAX3421E PROGRAMMING GUIDE](https://www.maximintegrated.com/en/design/technical-documents/app-notes/3/3785.html)
- [MAX3420E PROGRAMMING GUIDE](https://www.maximintegrated.com/en/design/technical-documents/app-notes/3/3598.html)
- [ESP-WROOM-02D](https://www.espressif.com/sites/default/files/documentation/esp-wroom-02u_esp-wroom-02d_datasheet_en.pdf)
- [USB in a NutShell](https://www.beyondlogic.org/usbnutshell/usb1.shtml)
- [Standard MIDI Files](https://arduinoplusplus.wordpress.com/2018/05/11/playing-midi-files-on-arduino-part-1-standard-midi-files/)
## Contributors

- Chen-Hsiang Feng <chen-hsiang.feng@tevofy.com>
- Yi-Fang Hsiung <hsiung@purdue.edu> 

## License
Copyright (C) 2021 Tevofy Technology LTD. All rights reserved.
Licensed under the [General Public License v2.0](LICENSE)

## EAGLE design hardware/MuroBox-USB.brd

Parts:
C5, C9: 1u; 0603-CAP
C6: 0.1u; 0603-CAP
C11: 10u_25V_0805; 0805-CAP
D2: LED-RGB-CA-THRUCLEAR; LED-RGB-THRU
J1: DIP-SCREW-TERMINAL(2P-2.54); H2-2.54-5.48X6.3MM
R2, R11: 1k; 0603-RES
R4: 100k; 0603-RES
R5: 22k; 0603-RES
R6: 100; 0603-RES
R7, R12, R16: 51k; 0603-RES
U$1: STUSB4500; QFN24
U$5, U$7, U$9, U$12: SMBJ24A; SMB-DIODE
U$10: AO4407ASOIC8; SO08
U$22, U$23, U$25, U$26: 1PIN_TEST_PAD; TP18R
U$27: USB-TYPE-C-90D-12P

Connections:
ALERT: U$1.19 (ALERT)
ATTACH: U$1.11 (ATTACH)
CC1: U$1.1 (CC1DB), U$1.2 (CC1), U$9.C, U$27.CC1
CC2: U$1.4 (CC2), U$1.5 (CC2DB), U$7.C, U$27.CC2
DISCH: R11.2, U$1.9 (DISCH)
GND: C5.1, C9.1, C11.1, J1.2, R12.2, U$1.3 (NC), U$1.6 (RESET), U$1.10 (GND), U$1.12 (ADDR0), U$1.13 (ADDR1), U$1.22 (VSYS), U$1.THERM (EP), U$5.A, U$7.A, U$9.A, U$12.A, U$26.TP, U$27.G1 (GND1), U$27.G2 (GND2), U$27.G3 (GND3), U$27.G4 (GND4), U$27.P$7 (SHELL1), U$27.P$8 (SHELL2), U$27.P$9 (SHELL3), U$27.P$18 (SHELL4); also elsewhere on the board
GPIO: U$1.15 (GPIO)
unnamed: D2.4 (BLUE_CATHODE), R7.1
unnamed: R2.2, U$1.18 (VBUS_VS_DISCH)
unnamed: C5.2, U$1.21 (VREG_1V2)
unnamed: R4.1, R5.2, R6.2, U$10.4 (G)
unnamed: C6.2, R6.1
unnamed: D2.1 (RED_CATHODE), R12.1
unnamed: D2.3 (GREEN_CATHODE), R16.1
POWER_PDO2: R16.2, U$1.20 (POWER_OK2)
POWER_PDO3: R7.2, U$1.14 (POWER_OK3)
SCL: U$1.7 (SCL), U$23.TP
SDA: U$1.8 (SDA), U$22.TP
VBUS: C11.2, R2.1, R4.2, U$1.24 (VDD), U$5.C, U$10.1 (S1), U$10.2 (S2), U$10.3 (S3), U$25.TP, U$27.V1 (VBUS1), U$27.V2 (VBUS2), U$27.V3 (VBUS3), U$27.V4 (VBUS4)
VBUS_EN_SNK: R5.1, U$1.16 (VBUS_EN_SNK)
VREG_2V7: C9.2, U$1.23 (VREG_2V7)
VSNK: C6.1, D2.2 (ANODE), J1.1, R11.1, U$10.5 (D1), U$10.6 (D2), U$10.7 (D3), U$10.8 (D4), U$12.C

Notes on the sheet:
C:/Users/Chen-Hsiang/Hardware/EMB-COOJU/»Ź§°ӼÐ.bmp
Testing Heads
PDO2: 12V 3A PDO3: 15V 3A
STUSB4500
Type-C 90 Degree 14P Female
Power PORT
Terminal Connector
For 共陽LED with VDD=5V, Vf=2.0V and If=20mA, R use 150 Ohm
VBUS_EN_SNK is active low (0 if Source attached)
Muro Box USB SHIELD

Parts:
C1: 10u_6.3V; 0603-CAP
C2, C7, C10: 0.1u; 0603-CAP
C21, C22, C23, C24, C25, C26, C49: DLP; 0603-CAP
D1: HB; LED-0603
IC1: ESP-WROOM-02FRONT-FACE; ESP-WROOM-02_FRONT-FACE
J3: CONN_02LOCK; 1X02_LOCK
R1, R10: 51k; 0603-RES
R3, R17: 2.2k; 0603-RES
R13, R14: DLP; 0603-RES
R25: 10k; 0603-RES
R28: 100k; 0603-RES
RSW1: ZEC11S-H4.5B2N-15K6-20P-SMD-565; EC11-CHINA
U$3, U$17: DIP-JST-3P-2.0; H3-2.0-8X4.5MM
U$4, U$8, U$14, U$16, U$18, U$19: 1PIN_TEST_PAD; TP18R
U$24: CONN_07X2; PHB-7X2

Connections:
A0: IC1.16 (TOUT)
DEBUG_TX: IC1.17 (IO16), R10.1, U$3.2, U$4.TP
EN: C10.2, IC1.2 (EN), R1.1
GND: C1.2, C2.2, C7.1, C10.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C49.1, D1.C, IC1.9 (GND1), IC1.13 (GND2), IC1.18 (GND3), IC1.P$37 (PAD), J3.1, R13.1, R14.1, R25.1, RSW1.C (COM), RSW1.M5, RSW1.M6, RSW1.SW1 (D), U$3.-, U$17.-, U$18.TP, U$24.P$2 (2), U$24.P$5 (5), U$24.P$6 (6), U$24.P$12 (12); also elsewhere on the board
MIDI_IN: C26.2, R3.1, U$24.P$8 (8)
MIDI_OUT: R17.1, U$24.P$4 (4)
unnamed: D1.A, R10.2
unnamed: IC1.10 (IO4), R13.2
unnamed: IC1.14 (IO5), R14.2
PACK_INT: C21.2, IC1.6 (IO15), R25.2, U$24.P$10 (10)
PACK_N_RESET: C7.2, C49.2, IC1.15 (RST), R28.1, U$24.P$14 (14); also elsewhere on the board
RR_A: C23.2, RSW1.A, U$24.P$9 (9)
RR_B: C24.2, RSW1.B, U$24.P$7 (7)
RR_E: C22.2, RSW1.SW2 (E), U$24.P$11 (11)
RXD/I2C: U$17.3
RXD/I2S: IC1.11 (RXD), R17.2, U$14.TP
TXD: IC1.12 (TXD), R3.2, U$8.TP, U$17.2
USB_CLK: IC1.3 (IO14); also elsewhere on the board
USB_CS: IC1.7 (IO2); also elsewhere on the board
USB_INT/GPIO0: IC1.8 (IO0), J3.2, U$16.TP; also elsewhere on the board
USB_SIMO: IC1.5 (IO13); also elsewhere on the board
USB_SOMI: IC1.4 (IO12); also elsewhere on the board
VCC: C1.1, C2.1, IC1.1 (3V3), R1.2, R28.2, U$19.TP, U$24.P$13 (13); also elsewhere on the board
VDD: C25.2, U$24.P$1 (1), U$24.P$3 (3); also elsewhere on the board

Notes on the sheet:
ESP8266 module
C:/Users/Chen-Hsiang/Hardware/EMB-COOJU/»Ź§°ӼÐ.bmp
Chen-Hsiang Feng
GPIOs 4 and 5 are the only ones that are always high impedance. All others do have internal pull-ups or are even driven low/high during boot. GPIOs 3, 12, 13 and 14 pulled HIGH during boot. Their actual state does not influence the boot process. GPIOs 0, 1, 2 and 15 are pulled HIGH during boot and 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
FDTI UART
FW Jumpers
Connector to Motherboard
Testing Heads
HEART BEAT
High during BOOT: GPIO16 GPIO3 (RX) GPIO1 (TX) GPIO10 GPIO9 Low during Boot: GPIO 4,5
GPIO states during boot https://rabbithole.wwwdotorg.org/2017/03/28/esp8266-gpio.html
Don't change 10K Pull Low for flash boot mode
USB_INT/GPIO0 Pulled upped by R29
PACK_INT is Active High

Parts:
C3: 0.47u; 0603-CAP
C4, C8, C12, C17, C18: 0.1u; 0603-CAP
C13, C19: 10u_6.3V; 0603-CAP
C14: 1u; 0603-CAP
C15, C16, C20: 30p; 0603-CAP
Q2: X503212MSB4SI - 12MHz; CRYSTAL-SMD-5X3
Q3: AO3400A_X0RB48; SOT23
R8: 51k; 0603-RES
R9: 100; 0603-RES
R18, R19: 33; 0603-RES
R23: 910k; 0603-RES
R24: 2.2k; 0603-RES
R29: 10k; 0603-RES
TP2: TPB1,27; B1,27
U1: MAX3421EEHJ+T; TQFP32-5MM
U2: TUSB320LAIRWBR; RWB0012A_TEX
U4: TPS1H200AQDGNRQ1; SOP65P490X110-9N
U$6: USB-TYPE-C-90D-12P

Connections:
D+: R18.2, U1.21 (D+)
D-: R19.2, U1.20 (D-)
GND: C3.1, C4.2, C8.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, Q3.2 (S), R24.1, U1.3 (GND), U1.19 (GND), U1.26 (GPIN0), U1.27 (GPIN1), U1.28 (GPIN2), U2.10 (GND), U2.11 (EN_N), U4.6 (GND), U4.9 (EP), U4.9_1 (EP), U4.9_2 (EP), U4.9_3 (EP), U4.9_4 (EP), U4.9_5 (EP), U4.9_6 (EP), U$6.G1 (GND1), U$6.G2 (GND2), U$6.G3 (GND3), U$6.G4 (GND4), U$6.P$7 (SHELL1), U$6.P$8 (SHELL2), U$6.P$9 (SHELL3), U$6.P$18 (SHELL4); also elsewhere on the board
ID: R9.1, U2.9 (ID)
ID_N: C4.1, Q3.3 (D), U1.32 (GPIN6), U4.1 (IN)
unnamed: TP2.TP, U4.3 (!FAULT)
unnamed: R24.2, U4.4 (CL)
unnamed: C3.2, U4.5 (DELAY)
unnamed: R18.1, U$6.D+1, U$6.D+2
unnamed: R19.1, U$6.D-1, U$6.D-2
unnamed: C16.2, Q2.1, U1.25 (X0)
unnamed: C15.2, Q2.3 (2), U1.24 (X1)
unnamed: U2.1 (CC1), U$6.CC1
unnamed: U2.2 (CC2), U$6.CC2
unnamed: R23.2, U2.4 (VBUS_DET)
unnamed: Q3.1 (G), R8.1, R9.2
PACK_N_RESET: C8.2, U1.12 (RES); also elsewhere on the board
USB_CLK: U1.13 (SCK); also elsewhere on the board
USB_CS: U1.14 (SS); also elsewhere on the board
USB_INT/GPIO0: R29.2, U1.18 (INT); also elsewhere on the board
USB_SIMO: U1.16 (MOSI); also elsewhere on the board
USB_SOMI: U1.15 (MISO); also elsewhere on the board
VBUS_MIDI: C14.2, C17.2, C19.2, C20.2, R23.1, U1.22 (VBCOMP), U4.7 (OUT), U$6.V1 (VBUS1), U$6.V2 (VBUS2), U$6.V3 (VBUS3), U$6.V4 (VBUS4)
VCC: C12.2, C13.2, C18.2, R8.2, R29.1, U1.2 (VL), U1.23 (VCC), U2.12 (VDD); also elsewhere on the board
VDD: U4.2 (DIAG_EN), U4.8 (VS); also elsewhere on the board

Notes on the sheet:
C:/Users/Chen-Hsiang/Hardware/EMB-COOJU/»Ź§°ӼÐ.bmp
PORT: NC - DRP (Leave unconnected if DRP mode is desired) ADDR:NC — GPIO mode (I2C is disabled) EN_N: Enable signal; active low. Pulled up to VDD internally to disable the TUSB320L device. If controlled externally, must be held low at least for 50 ms after VDD has reached its valid voltage level. I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
USB in a NutShell https://www.beyondlogic.org/usbnutshell/usb1.shtml
I_out = (V_CL x K_CL)/R_CL = 0.8 x 2500 / 2.2k = 0.91 A
tdl2 = C_DELAY x V_dl(ref) / I_dl(chg) = 0.47u x 1.45 / (4.5x10^-6) = 0.15 s
Letch-off mode
Leave Float
ID is open drain active low Already pulled up by GPIN (ID high -> USB peripheral ID Low - > USB host)
Rd (pulled down) >=150K for IN and DIAG_EN
ID_N high -> USB host ID_N Low - > USB peripheral (Low if no plug in)

Board: 2 copper layers, 81.4 x 27.5 mm, 83 parts (17 on the bottom side), 56 nets.

Notices in the files:
parts and their libraries:
SparkFun-Passives: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
COPYRIGHT: Copyright (C) 2018 Accelerated Designs. All rights reserved
